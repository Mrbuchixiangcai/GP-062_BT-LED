# Keil uVision project GP-062_BT-LED.uvproj, settings and files
target GP-062 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: GP-062_BT-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Hardware;..\Hardware\BT;..\Hardware\KEY;..\Hardware\LED;..\Hardware\SystemSleep
  group User
    ./: STARTUP.A51
    ../User/: main.c
  group Hardware
    ../Hardware/: app_main.c
    ../Hardware/BT/: BT_Mode.c
    ../Hardware/KEY/: Key_Mode.c
    ../Hardware/LED/: LED_Drive.c LED_Mode.c
    ../Hardware/SystemSleep/: sys_sleep.c
